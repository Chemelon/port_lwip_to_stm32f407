# Keil uVision project lwip_port.uvprojx, settings and files
target no_sys (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lwip_port
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\bsp_drivers;..\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\Include;..\STM32F4xx_DSP_StdPeriph_Lib\inc;..\usr;..\lwip-2.1.2\include;..\lwip-2.1.2\ports;..\FreeRTOS\include;..\FreeRTOS\port;..\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group std_fw_core
    ../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Source/: system_stm32f4xx.c
    ../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Source/arm/: startup_stm32f40xx.s
  group std_fw_lib
    ../STM32F4xx_DSP_StdPeriph_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ../usr/: main.c stm32f4xx_it.c stm32f4xx_conf.h
    ../cm_backtrace/: cmb_cfg.h
  group bsp_drivers
    ../bsp_drivers/: delay.c eth.c lan8720.c led.c stm32f4x7_eth.c usart.c
  group lwip/core
    ../lwip-2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/api
    ../lwip-2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/netif
    ../lwip-2.1.2/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/ports
    ../lwip-2.1.2/ports/: ethernetif.c lwipopts.h
    ../lwip-2.1.2/ports/arch/: cc.h
  group freertos/src
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/ports
    ../FreeRTOS/port/: port.c heap_4.c
  group backtrace
    ../cm_backtrace/: cm_backtrace.c
    ../cm_backtrace/fault_handler/keil/: cmb_fault.S
  group doc
    ../: README.md
